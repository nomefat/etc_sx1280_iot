# Keil uVision project etc_project.uvprojx, settings and files
target etc_project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: etc_project +hex
  AfterMake: C:/Keil_v5/ARM/ARMCC/bin/fromelf.exe --bin -o ./etc_n1.bin ./etc_project/etc_project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;             ..\User\RF\sx1280;             ..\User\RF;             ..\User\Debug;             ..\User\4G;             ..\User\IO_LED;             ..\User\sys;C:/Users/Administrator.SC-201906042026/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.0/Drivers/STM32F4xx_HAL_Driver/Inc;C:/Users/Administrator.SC-201906042026/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;C:/Users/Administrator.SC-201906042026/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include;C:/Users/Administrator.SC-201906042026/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Rf
    ../User/RF/sx1280/: sx1280.c sx1280-hal.c radio.c
    ../User/RF/: etc_rf.c
  group Application/User/4g
    ../User/4G/: gprs_comm.c gprs_4g_app.c gprs_hal.c
    ../User/sys/: flash.c
  group Application/User/Io_Led
    ../User/IO_LED/: io_led.c usb_key.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c dma.c i2c.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/Debug
    ../User/Debug/: debug_uart.c debug.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/Administrator.SC-201906042026/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
